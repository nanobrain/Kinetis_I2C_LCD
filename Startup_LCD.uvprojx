# Keil uVision project Startup_LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Startup_LCD
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Listings
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Listings/: fsl_device_registers.h HD44780.c HD44780.h main.c startup_MKL25Z4.s system_MKL25Z4.c Declarations.h
    ./: I2C.c
